# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: INT0.c IR.c main.c Motor.c Timer0.c Timer1.c INT0.h IR.h Motor.h Timer0.h Timer1.h AT24C02.c AT24C02.h Delay.c Delay.h DS18B20.c DS18B20.h I2C.c I2C.h LCD1602.c LCD1602.h OneWire.c OneWire.h
